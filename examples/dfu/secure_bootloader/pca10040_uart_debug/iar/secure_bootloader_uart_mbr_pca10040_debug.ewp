# IAR project secure_bootloader_uart_mbr_pca10040_debug.ewp, settings and files
configuration nrf52832_xxaa_mbr (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; DEBUG_NRF; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74; NRF_DFU_DEBUG_VERSION; NRF_DFU_SETTINGS_VERSION=1; SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION; uECC_ENABLE_VLI_API=0; uECC_OPTIMIZATION_LEVEL=3; uECC_SQUARE_FUNC=0; uECC_SUPPORT_COMPRESSED_POINT=0; uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  ICCARM.CCIncludePath2: ..\..\config\secure_bootloader_uart_mbr_pca10040_debug; ..\..\config; ..\..\..\..\..\components\boards; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\components\libraries\bootloader; ..\..\..\..\..\components\libraries\bootloader\dfu; ..\..\..\..\..\components\libraries\bootloader\serial_dfu; ..\..\..\..\..\components\libraries\crc32; ..\..\..\..\..\components\libraries\crypto; ..\..\..\..\..\components\libraries\crypto\backend\cc310; ..\..\..\..\..\components\libraries\crypto\backend\cc310_bl; ..\..\..\..\..\components\libraries\crypto\backend\cifra; ..\..\..\..\..\components\libraries\crypto\backend\mbedtls; ..\..\..\..\..\components\libraries\crypto\backend\micro_ecc; ..\..\..\..\..\components\libraries\crypto\backend\nrf_hw; ..\..\..\..\..\components\libraries\crypto\backend\nrf_sw; ..\..\..\..\..\components\libraries\crypto\backend\oberon; ..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\components\libraries\experimental_log; ..\..\..\..\..\components\libraries\experimental_log\src; ..\..\..\..\..\components\libraries\experimental_memobj; ..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\components\libraries\sha256; ..\..\..\..\..\components\libraries\slip; ..\..\..\..\..\components\libraries\sortlist; ..\..\..\..\..\components\libraries\stack_info; ..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\components\libraries\timer\experimental; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\softdevice\mbr\nrf52832\headers; ..\..\..\..\..\components\toolchain\cmsis\include; ..\..; ..\..\..\..\..\external\fprintf; ..\..\..\..\..\external\micro-ecc\micro-ecc; ..\..\..\..\..\external\nano-pb; ..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\integration\nrfx; ..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\modules\nrfx; ..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: secure_bootloader_uart_mbr_pca10040_debug.hex
  ILINK.IlinkOutputFile: secure_bootloader_uart_mbr_pca10040_debug.out
  ILINK.IlinkIcfFile: secure_bootloader_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../: dfu_public_key.c
    ../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../components/boards/: boards.c
  group nano-pb
    ../../../../../external/nano-pb/: pb_common.c pb_decode.c
  group None
    ../../../../../modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
  group nRF_Bootloader
    ../../../../../components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_final.c nrf_bootloader_dfu_timers.c nrf_bootloader_fw_activation.c nrf_bootloader_info.c nrf_bootloader_wdt.c
  group nRF_Crypto
    ../../../../../components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
  group nRF_Crypto backend nRF sw
    ../../../../../components/libraries/crypto/backend/nrf_sw/: nrf_sw_backend_hash.c
  group nRF_Crypto backend uECC
    ../../../../../components/libraries/crypto/backend/micro_ecc/: micro_ecc_backend_ecc.c micro_ecc_backend_ecdh.c micro_ecc_backend_ecdsa.c
  group nRF_DFU
    ../../../../../components/libraries/bootloader/dfu/: dfu-cc.pb.c nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_req_handler.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c nrf_dfu_validation.c nrf_dfu_ver_validation.c
    ../../../../../components/libraries/bootloader/serial_dfu/: nrf_dfu_serial_uart.c
  group nRF_Drivers
    ../../../../../integration/nrfx/legacy/: nrf_drv_uart.c
    ../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../../../modules/nrfx/drivers/src/: nrfx_uart.c nrfx_uarte.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../components/libraries/timer/experimental/: app_timer2.c drv_rtc.c
    ../../../../../components/libraries/crc32/: crc32.c
    ../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    ../../../../../components/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../components/libraries/sha256/: sha256.c
    ../../../../../components/libraries/slip/: slip.c
  group nRF_Log
    ../../../../../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_micro-ecc
    ../../../../../external/micro-ecc/nrf52hf_iar/armgcc/: micro_ecc_lib_nrf52.a
  group nRF_Segger_RTT
    ../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group nRF_Serial_DFU
    ../../../../../components/libraries/bootloader/serial_dfu/: nrf_dfu_serial.c
